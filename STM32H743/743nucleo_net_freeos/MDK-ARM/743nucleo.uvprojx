# Keil uVision project 743nucleo.uvprojx, settings and files
target 743nucleo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: 743nucleo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc; ../LWIP/App; ../LWIP/Target; C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/LwIP/src/include; C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/LwIP/system; C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Drivers/STM32H7xx_HAL_Driver/Inc; C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/FreeRTOS/Source/include; C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1; C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Drivers/BSP/Components/lan8742; C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/LwIP/src/include/netif/ppp; C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Drivers/CMSIS/Device/ST/STM32H7xx/Include; C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/LwIP/src/include/lwip; C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/LwIP/src/include/lwip/apps; C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/LwIP/src/include/lwip/priv; C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/LwIP/src/include/lwip/prot; C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/LwIP/src/include/netif; C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/LwIP/src/include/posix; C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/LwIP/src/include/posix/sys; C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/LwIP/system/arch; C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Drivers/CMSIS/Include
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c freertos.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c tcpecho.c udpecho.c app_ethernet.c
  group Application/User/LwIP/App
    ../LWIP/App/: lwip.c
  group Application/User/LwIP/Target
    ../LWIP/Target/: ethernetif.c
  group Drivers/BSP/Components
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Drivers/BSP/Components/lan8742/: lan8742.c
  group Drivers/STM32H7xx_HAL_Driver
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Middlewares/LwIP
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/LwIP/src/netif/: ethernet.c slipif.c lowpan6.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.0/Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
software components: CMSIS:CORE 5.1.1
