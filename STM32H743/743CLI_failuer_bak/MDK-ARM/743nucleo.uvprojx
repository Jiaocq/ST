# Keil uVision project 743nucleo.uvprojx, settings and files
target 743nucleo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: 743nucleo
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Inc;C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.2/Drivers/STM32H7xx_HAL_Driver/Inc;C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.2/Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.2/Middlewares/Third_Party/FreeRTOS/Source/include;C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.2/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.2/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.2/Drivers/CMSIS/Device/ST/STM32H7xx/Include;C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.2/Drivers/CMSIS/Include
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User
    ../Src/: main.c gpio.c dma.c freertos.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c FreeRTOS_CLI.c Sample-CLI-commands.c UARTCommandConsole.c serial.c
  group Drivers/STM32H7xx_HAL_Driver
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.2/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.2/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.2/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.2/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_H7_V1.3.2/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
software components: CMSIS:CORE 4.3.0
