# Keil uVision project 107.uvprojx, settings and files
target 107 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: 107
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c include: ../Core/Inc;                   ../LWIP/App;                   ../LWIP/Target;                   C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/LwIP/src/include;                   C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/LwIP/system;                   C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Drivers/STM32F1xx_HAL_Driver/Inc;                   C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                   C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/LwIP/src/include/netif/ppp;                   C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Drivers/CMSIS/Device/ST/STM32F1xx/Include;                   C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/LwIP/src/include/lwip;                   C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/LwIP/src/include/lwip/apps;                   C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/LwIP/src/include/lwip/priv;                   C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/LwIP/src/include/lwip/prot;                   C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/LwIP/src/include/netif;                   C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/LwIP/src/include/posix;                   C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/LwIP/src/include/posix/sys;                   C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/LwIP/system/arch;                   C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Drivers/CMSIS/Include;                  C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/FreeRTOS/Source/include;                  C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                  C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: 107\107.sct
  group Application/MDK-ARM
    ./: startup_stm32f107xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c freertos.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Application/User/LwIP/App
    ../LWIP/App/: lwip.c
  group Application/User/LwIP/Target
    ../LWIP/Target/: ethernetif.c
  group Drivers/STM32F1xx_HAL_Driver
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_eth.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/LwIP
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/LwIP/src/netif/: ethernet.c slipif.c lowpan6.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/FreeRTOS
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    C:/Users/Third/STM32Cube/Repository/STM32Cube_FW_F1_V1.7.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 4.3.0
